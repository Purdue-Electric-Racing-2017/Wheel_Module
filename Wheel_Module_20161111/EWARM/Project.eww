<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Wheel_Module_20161111.ewp</path>
  </project>
  <batchBuild />
</workspace>
